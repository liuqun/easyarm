<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DriverLib\src\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\projects\LED&#x6D4B;&#x8BD5;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\projects\&#x901A;&#x8BAF;&#x5B9e;&#x9A8C;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\projects\&#x5750;&#x6807;&#x8BA1;&#x7B97;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


